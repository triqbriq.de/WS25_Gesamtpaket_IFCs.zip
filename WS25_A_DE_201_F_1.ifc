Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_201_F_1.ifc
Time: 2026-08-31T13:10:04
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (34)
Name | In | Material
9 x WS25_A_DE_201_F_1 | TRIQBRIQ_Materials | Abdichtung
WS25_A_DE_201_F_1 | TRIQBRIQ_Materials | Custom (1)
WS25_A_DE_201_F_1 | Dübel | Soil 05
WS25_A_DE_201_F_1 | Dübel | Faserschutzmatte
WS25_A_DE_201_F_1 | Dübel | Holzfasser
WS25_A_DE_201_F_1 | Dübel | Custom
WS25_A_DE_201_F_1 | Dübel | Wood 25
7 x WS25_A_DE_201_F_1 | Dübel | Wood 28
WS25_A_DE_201_F_1 | Dübel
WS25_A_DE_201_F_1 | Dübel | Grass 01
3 x WS25_A_DE_201_F_1 | Dübel | Silver 02, Rough
WS25_A_DE_201_F_1 | Dübel | Mörtel
WS25_A_DE_201_F_1 | Dübel | Plaster 11
WS25_A_DE_201_F_1 | Dübel | Gravel 02
3 x WS25_A_DE_201_F_1 | Dübel | Gravel 02 (1)
WS25_A_DE_201_F_1 | Dübel | Strohbauplatte
