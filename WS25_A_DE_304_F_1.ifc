Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_304_F_1.ifc
Time: 2026-08-31T13:16:07
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (80)
In: TRIQBRIQ_Materials
Name | Material
WS25_A_DE_304_F_1 | Concrete Grainy
20 x WS25_A_DE_304_F_1 | Custom
23 x WS25_A_DE_304_F_1 | Wood 25
31 x WS25_A_DE_304_F_1 | Wood 28
WS25_A_DE_304_F_1 | Mauersperrbahn
3 x WS25_A_DE_304_F_1 | Silver 02, Rough
WS25_A_DE_304_F_1
