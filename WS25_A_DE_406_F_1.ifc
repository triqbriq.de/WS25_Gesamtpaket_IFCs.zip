Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_406_F_1.ifc
Time: 2026-08-31T13:22:54
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (289)
In: Kämmnagel
Name | Material
68 x WS25_A_DE_406_F_1 | Custom
144 x WS25_A_DE_406_F_1
74 x WS25_A_DE_406_F_1 | Wood 25
WS25_A_DE_406_F_1 | Wood 28
2 x WS25_A_DE_406_F_1 | Silver 02, Rough
