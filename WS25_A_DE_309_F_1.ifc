Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_309_F_1.ifc
Time: 2026-08-31T13:19:01
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (41)
Name | In | Material
5 x WS25_A_DE_309_F_1 | TRIQBRIQ_Materials
WS25_A_DE_309_F_1 | TRIQBRIQ_Materials | Concrete Grainy
WS25_A_DE_309_F_1 | TRIQBRIQ_Materials | Wood 10, Strip
3 x WS25_A_DE_309_F_1 | TRIQBRIQ_Materials | Steinwolle
WS25_A_DE_309_F_1 | Dübel | Glas
WS25_A_DE_309_F_1 | Dübel | Holzfasser
2 x WS25_A_DE_309_F_1 | Dübel | Custom
WS25_A_DE_309_F_1 | Dübel | Cork 01
4 x WS25_A_DE_309_F_1 | Dübel | Wood 28
4 x WS25_A_DE_309_F_1 | Dübel | Silver 02, Rough
3 x WS25_A_DE_309_F_1 | Dübel | Mörtel
WS25_A_DE_309_F_1 | Dübel | Plaster 11
2 x WS25_A_DE_309_F_1 | Dübel | Gravel 02
6 x WS25_A_DE_309_F_1 | Dübel | Putz
WS25_A_DE_309_F_1 | Dübel | Road 04
3 x WS25_A_DE_309_F_1 | Dübel | Window Frame
2 x WS25_A_DE_309_F_1 | Dübel | Steel 15, Grid
