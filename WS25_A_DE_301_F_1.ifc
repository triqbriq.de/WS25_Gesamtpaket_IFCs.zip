Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_301_F_1.ifc
Time: 2026-08-31T13:13:25
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (25)
Name | In | Material
5 x WS25_A_DE_301_F_1 | TRIQBRIQ_Materials
WS25_A_DE_301_F_1 | TRIQBRIQ_Materials | Concrete Grainy
2 x WS25_A_DE_301_F_1 | Dübel | Wood 25
12 x WS25_A_DE_301_F_1 | Dübel | Wood 28
2 x WS25_A_DE_301_F_1 | Dübel | Silver 02, Rough
3 x WS25_A_DE_301_F_1 | Dübel | Plaster
