Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_502_F_1.ifc
Time: 2026-08-31T13:24:01
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (16)
In: Dübel
Name | Material
WS25_A_DE_502_F_1 | Plaster 04
WS25_A_DE_502_F_1 | Holzfasser
10 x WS25_A_DE_502_F_1 | Wood 28
WS25_A_DE_502_F_1
WS25_A_DE_502_F_1 | Mörtel
WS25_A_DE_502_F_1 | Plaster 11
WS25_A_DE_502_F_1 | Strohbauplatte
