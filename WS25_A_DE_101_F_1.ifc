Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\x.ifc
Time: 2026-08-31T13:06:49
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (93)
Name | In | Material
4 x WS25_A_DE_101_F_1 | TRIQBRIQ_Materials
4 x WS25_A_DE_101_F_1 | TRIQBRIQ_Materials | Concrete Grainy
4 x WS25_A_DE_101_F_1 | Dübel | Soil 05
2 x WS25_A_DE_101_F_1 | Dübel | Custom
WS25_A_DE_101_F_1 | Dübel | Wood 25
38 x WS25_A_DE_101_F_1 | Dübel | Wood 28
4 x WS25_A_DE_101_F_1 | Dübel | Grass 01
4 x WS25_A_DE_101_F_1 | Dübel | Mauersperrbahn
12 x WS25_A_DE_101_F_1 | Dübel | Silver 02, Rough
4 x WS25_A_DE_101_F_1 | Dübel | Mörtel
16 x WS25_A_DE_101_F_1 | Dübel | Plaster
