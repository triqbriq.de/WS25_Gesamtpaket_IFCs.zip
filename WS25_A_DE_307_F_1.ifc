Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\Andrei\Desktop\Rhino Exports For Revit\WS25_A_DE_307_F_1.ifc
Time: 2026-08-31T13:18:04
Author: Andrei
Organization: LAPTOP-C9IBRSKE
Written by: ggRhinoIFC v26.8.29.8 by Geometry Gym Pty Ltd built 2026-08-28T22:06:46
Made in: Geometry Gym - ggRhinoIFC - 26.8.29.8
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (71)
Name | In | Material
10 x WS25_A_DE_307_F_1 | TRIQBRIQ_Materials | Abdichtung
WS25_A_DE_307_F_1 | TRIQBRIQ_Materials | Gravel 01
WS25_A_DE_307_F_1 | TRIQBRIQ_Materials | Custom (1)
WS25_A_DE_307_F_1 | TRIQBRIQ_Materials | Wood 10, Strip
WS25_A_DE_307_F_1 | TRIQBRIQ_Materials | Steinwolle
WS25_A_DE_307_F_1 | Dübel | Glas
2 x WS25_A_DE_307_F_1 | Dübel | Holzfasser
4 x WS25_A_DE_307_F_1 | Dübel | Custom
WS25_A_DE_307_F_1 | Dübel | Wood 25
WS25_A_DE_307_F_1 | Dübel | Cork 01
26 x WS25_A_DE_307_F_1 | Dübel | Wood 28
WS25_A_DE_307_F_1 | Dübel
7 x WS25_A_DE_307_F_1 | Dübel | Silver 02, Rough
5 x WS25_A_DE_307_F_1 | Dübel | Mörtel
2 x WS25_A_DE_307_F_1 | Dübel | Plaster 11
3 x WS25_A_DE_307_F_1 | Dübel | Putz
WS25_A_DE_307_F_1 | Dübel | Road 04
3 x WS25_A_DE_307_F_1 | Dübel | Window Frame
